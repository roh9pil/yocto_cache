## example/hellolayer/conf/layer.conf
```bitbake
BBPATH .= ":${LAYERDIR}"
BBFILES += "${LAYERDIR}/*.bb"
BBFILE_COLLECTIONS += "hellolayer"
BBFILE_PATTERN_hellolayer := "^${LAYERDIR_RE}/"
```
